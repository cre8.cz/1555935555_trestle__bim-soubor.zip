Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-03-17T13:18:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 17 13:18:10 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{DEE2BFA7-622B-4718-A9AB-428EDEBAE1BA}\ifc * Database version: 5507 * Database creation date: Thu Mar 17 13:18:09 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 17 13:18:09 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 17 13:18:09 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"), 2015_Bench_Viccarbe_Trestle:Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"):130668
In: Nivel 1
Type - ElementType: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"); Material: Oak Wood, Lacquered tube, Fabric
Type - Construction - Number Legs: 2; Number Seats: 1
Type - Identity Data - Bimetica: www.bimetica.com; Collection: TRESTLE; Content Revision Date: 03/03/2016; Created by: Bimetica Parametric Design Services S.L.; Description: With all the usual elegance of Pawson, this bench once again surprises us with its exquisite proportions. Solid oak feet and a subtle seat upholstered in a plain or padded finish in our collection of fabrics and leathers. Ideal both for the home - in its short version - and for waiting areas and hallways in smart public spaces.; Essays UNE: http://www.viccarbe.com/archivos/viccarbe-test-trestle-(bench)-92.pdf; General Dimensions (inches): 17.71"x17.71"x70.87"; General Dimensions (mm): 450x450x1800 mm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: Trestle Bench; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product URL: http://www.viccarbe.com/product.php?id=23534571171dc1c; Reference Code: TRS; Series: Benches; Technical information: http://www.viccarbe.com/archivos/viccarbe-trestle-en-info-49.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"); URL: http://www.viccarbe.com/; Warranty: 5 Years; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Backrest Material: Fabric; Base Material: Oak Wood; Frame Material: Lacquered tube; Materials - Fabrics: http://www.viccarbe.com/archivos/VICCARBE_Kvadrat_fabrics.pdf; Materials - Lacquers: http://www.viccarbe.com/archivos/VICCARBE_lacquers_lacados.pdf; Materials - Leather: http://www.viccarbe.com/archivos/VICCARBE_leather.pdf; Materials - Vinyl: http://www.viccarbe.com/archivos/VICCARBE_polipiel_vinyl.pdf; Materials - Woods: http://www.viccarbe.com/archivos/VICCARBE_woods_maderas.pdf; Seat Material: Fabric
Type - Other - Category: Furniture; Family Name: 2015_Bench_Viccarbe_Trestle; Seat Height (mm): 410 mm
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Cantidades de mobiliario - Descripción de unidad: 2015_Bench_Viccarbe_Trestle: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"); Tipo: 2015_Bench_Viccarbe_Trestle: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"); Descripción: With all the usual elegance of Pawson, this bench once again surprises us with its exquisite proportions. Solid oak feet and a subtle seat upholstered in a plain or padded finish in our collection of fabrics and leathers. Ideal both for the home - in its short version - and for waiting areas and hallways in smart public spaces.; Fabricante: VICCARBE; Modelo: Trestle Bench; URL: http://www.viccarbe.com/
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Backrest: no
Dimensions - Area: 3.21862 m2; Volume: 0.0470484 m3
Other - Connection Distance: 1000 mm; Connection Distance 2: 1000 mm; End Leg: no; Family: 2015_Bench_Viccarbe_Trestle: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"); Family and Type: 2015_Bench_Viccarbe_Trestle: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"); Length (mm): 1200 mm; Number Connection Control: 2; Number Legs Control: 2; Type: 2015_Bench_Viccarbe_Trestle: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87"); Type Id: 2015_Bench_Viccarbe_Trestle: Simple Bench (45x45x180 cm / 17.71"x17.71"x70.87")
Phasing - Phase Created: Fase 1
